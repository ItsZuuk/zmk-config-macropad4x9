## config/boards/shields/macropad4x9/Kconfig.defconfig
```kconfig
if SHIELD_Macropad4x9

config ZMK_KEYBOARD_NAME
    default "Macropad4x9"

endif  
```
